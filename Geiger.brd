# Repository DanHert/Geiger2.0

## EAGLE design Geiger.brd

Parts:
C1, C8: 100n; C0805
C2, C3: 4n7 500V; C1206
C4: 22p 500V; C050-024X044
C5, C6: 10u; C0805
C9: 100n 500V; C150-054X183
D4: 1N4148W; SOD123
D5, D6, D7: EGL1G; SOD80C
IC1: TINY15LS; SOIC8
IC3: TP4056; SOP-8
JP2: SSD1306; 1X04
JP3: PROGRAMMING; 1X04
JP4: RESET; 1X01
R1: 10K; R0805
R2: 0R39; R1206
R3, R4, R6, R9, R11, R12, R13, R14: 1M; R0805
R5, R8: 4k7; R0805
R7: 3K; R0805
R10: 50K; R0805
S1, S2: TL36PO; TL3XPO
SP1, SP2: AL11P
T1: BC807; SOT23-BEC
T3, T4, T5: 3904; SOT23-BEC
TRANSFORMER: CCFL
U2: USB; USB-MICRO-SMD
U$1: SBM-20
ZD1, ZD2: 200V; MELF-MLL41

Connections:
200V: ZD1.A, ZD2.C
200V2: C2.2, D5.C, D6.A
400V: C9.1, D7.C, R12.1, ZD1.C
400V2: C4.1, R3.2, R12.2
400V3: C3.2, D6.C, D7.A
ALARM: C8.1, IC1.3 ((ADC2)PB3), R8.2, R9.2, R10.2
GND: C1.2, C3.1, C5.2, C6.2, C8.2, C9.2, D5.A, IC1.4 (GND), IC3.1 (TEMP), IC3.3 (GND), IC3.P$1 (THPAD), JP2.2, JP3.4, R7.1, R10.1, S2.1 (O), T3.E, T4.E, T5.E, U2.GND1 (GND), U$1.P$2, ZD2.A
unnamed: SP2.+ (2), T4.C
unnamed: C2.1, TRANSFORMER.HV
unnamed: R8.1, T4.B
unnamed: R1.2, T5.B
unnamed: R3.1, R6.2
unnamed: R6.1, R13.2
unnamed: R14.1, U$1.P$1
unnamed: R13.1, R14.2
unnamed: R5.2, R11.1, T1.C
unnamed: C4.2, D4.A, R4.1, T1.B
unnamed: IC1.1 ((ADC0)PB5), JP4.1
unnamed: R5.1, T3.B
unnamed: S1.2, S1.3 (S)
unnamed: C6.1, IC3.4 (VCC), IC3.8 (CE), R2.1
unnamed: T5.C, TRANSFORMER.TR1, TRANSFORMER.TR2
unnamed: IC3.2 (PROG), R7.2
unnamed: IC1.5 ((AREF)PB0), JP2.3, JP3.3
unnamed: IC1.6 ((OCP)PB1), JP2.4, JP3.2
OSC: IC1.2 ((ADC3)PB4), R1.1
PULSE: IC1.7 ((ADC1)PB2), JP3.1, R11.2
SPKR: SP1.+ (2), T3.C
V+: JP2.1, S2.2, SP1.- (1)
VCC: C1.1, C5.1, D4.C, IC1.8 (VCC), IC3.5 (BAT), R4.2, R9.1, S1.1 (O), S2.3 (S), SP2.- (1), T1.E, TRANSFORMER.V+
VCCUSB: R2.2, U2.VBUS1 (VBUS)

Board: 2 copper layers, 120.3 x 47.6 mm, 44 parts (0 on the bottom side), 31 nets.

## Commit log

2017-10-20 ahoj
2017-10-21 dalsi
2017-10-22 co asi
2017-10-24 fsldi
2017-10-31 Added some vias
2017-10-31 Minor updates
